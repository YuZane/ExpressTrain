# Keil uVision project ExpressTrain.uvprojx, settings and files
target ExpressTrain (6180000::V6.18::ARMCLANG)
  device: MM32F5333D7PV MindMotion
  pack: MindMotion.MM32F5330_DFP.0.5.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Star-MC1") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: ExpressTrain +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,CUSTOM_HSE_VAL
  c include: ..\..\Source;..\..\Device\CMSIS\Core\Include;..\..\Device\MM32F5330\HAL_Lib\inc;..\..\Device\MM32F5330\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\Device\MM32F5330\Source\mm32f5330.sct
  group APP
    ../: main.c mm32f5330_it.c platform.c uart_interrupt.c gpio_key_input.c exti_interrupt.c i2c_master_polling.c paj7620u2.c rgbandhsv.c ws2812b_tim1_1_pwm_dma.c
  group HAL_LIB
    ../../Device/MM32F5330/HAL_Lib/src/: hal_adc.c hal_bkp.c hal_comp.c hal_cordic.c hal_crcpoly.c hal_crs.c hal_dac.c hal_dbg.c hal_dma.c hal_exti.c hal_flash.c hal_flexcan.c hal_gpio.c hal_i2c.c hal_i3c.c hal_iwdg.c hal_lptim.c hal_lpuart.c hal_mds.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_spi.c hal_sram.c hal_syscfg.c hal_tim.c hal_uart.c hal_uid.c hal_usart.c hal_wwdg.c
  group STARTUP
    ../../Device/MM32F5330/Source/: system_mm32f5330.c
    ../../Device/MM32F5330/Source/KEIL_StartAsm/: startup_mm32f5330_keil.c
